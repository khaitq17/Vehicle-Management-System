# Keil uVision project Project.uvprojx, settings and files
target Vehicle_Management_System_Project (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\MFRC522;.\FatFs;.\FatFs\src;.\FatFs\src\option;..\Vehicle Management Project;..\Project
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Inc
    ./: Main.h GPIO.h TIM.h SPI.h UART.h System_Handler.h
  group Src
    ./: Main.c GPIO.c TIM.c SPI.c UART.c System_Handler.c
  group Servo
    ./: Servo.h Servo.c
  group MFRC522
    ./MFRC522/: MFRC522.h MFRC522.c
  group SD Card
    ./FatFs/: fatfs.c fatfs.h fatfs_sd.c fatfs_sd.h ffconf.h user_diskio.c user_diskio.h
    ./FatFs/src/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h ffconf_template.h integer.h
    ./FatFs/src/option/: syscall.c unicode.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
